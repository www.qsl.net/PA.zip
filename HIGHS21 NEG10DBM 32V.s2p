!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 19:39:43
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 59.7 dB at 2.773 GHz (marker M1)
!   |S21| within 3 dB of that: 3.492 GHz to 6.1 GHz (2.608 GHz wide, 54.4 % of centre) (the widest 1 of 2)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -69.9  -  -
! 122.2 kHz  -  -63.7  -  -
! 191.8 kHz  -  -53.8  -  -
! 635.6 kHz  -  -69.1  -  -
! 4.039 MHz  -  -73.4  -  -
! 25.5 MHz  -  -68.9  -  -
! 36.55 MHz  -  -63.7  -  -
! 61.44 MHz  -  -56.7  -  -
! 68.17 MHz  -  -65.5  -  -
! 162 MHz  -  -64.3  -  -
! 333 MHz  -  -52.8  -  -
! 445.4 MHz  -  -26.7  -  -
! 643 MHz  -  -7.7  -  -
! 780.6 MHz  -  -17.5  -  -
! 890.4 MHz  -  6.6  -  -
! 1.03 GHz  -  -3.8  -  -
! 1.096 GHz  -  -6.9  -  -
! 1.268 GHz  -  -4.2  -  -
! 1.855 GHz  -  55.6  -  -
! 2.773 GHz  -  59.7  -  -
! 5.698 GHz  -  59.2  -  -
! 6.5 GHz  -  48.6  -  -
