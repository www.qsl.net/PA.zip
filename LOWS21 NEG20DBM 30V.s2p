!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 18:55:40
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 57.3 dB at 409.9 MHz (marker M1)
!   |S21| within 3 dB of that: 6.37 MHz to 529.4 MHz (523.1 MHz wide, 195 % of centre)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -47.7  -  -
! 115.7 kHz  -  -45.3  -  -
! 164.7 kHz  -  -46.0  -  -
! 340.7 kHz  -  -47.1  -  -
! 635.6 kHz  -  -8.9  -  -
! 782.3 kHz  -  1.3  -  -
! 923.8 kHz  -  -0.8  -  -
! 1.324 MHz  -  23.3  -  -
! 4.039 MHz  -  50.6  -  -
! 25.5 MHz  -  56.7  -  -
! 162 MHz  -  56.1  -  -
! 409.9 MHz  -  57.3  -  -
! 693.9 MHz  -  51.1  -  -
! 1.03 GHz  -  5.9  -  -
! 1.096 GHz  -  2.4  -  -
! 1.208 GHz  -  -47.6  -  -
! 1.303 GHz  -  -58.5  -  -
! 2.222 GHz  -  -54.7  -  -
! 2.569 GHz  -  -51.8  -  -
! 3.252 GHz  -  -57.4  -  -
! 3.893 GHz  -  -48.6  -  -
! 6.5 GHz  -  -56.5  -  -
