!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 15:18:24
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 64.3 dB at 934.7 MHz (marker M1)
!   |S21| within 3 dB of that: 769.6 MHz to 2.112 GHz (1.342 GHz wide, 93.2 % of centre) (the widest 1 of 3)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -22.0  -  -
! 267.4 kHz  -  -29.4  -  -
! 635.6 kHz  -  -29.1  -  -
! 4.039 MHz  -  -43.9  -  -
! 25.5 MHz  -  -40.5  -  -
! 28.88 MHz  -  -49.6  -  -
! 33.63 MHz  -  -35.8  -  -
! 110.7 MHz  -  -33.5  -  -
! 162 MHz  -  3.4  -  -
! 356.9 MHz  -  59.6  -  -
! 934.7 MHz  -  64.3  -  -
! 1.03 GHz  -  63.1  -  -
! 2.642 GHz  -  63.0  -  -
! 2.871 GHz  -  47.3  -  -
! 3.141 GHz  -  10.8  -  -
! 3.461 GHz  -  17.5  -  -
! 3.735 GHz  -  -19.4  -  -
! 4.115 GHz  -  -35.0  -  -
! 4.996 GHz  -  -32.3  -  -
! 5.505 GHz  -  -31.8  -  -
! 6.15 GHz  -  -25.0  -  -
! 6.5 GHz  -  -33.5  -  -
