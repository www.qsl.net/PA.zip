!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 15:14:16
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 62.6 dB at 2.348 GHz (marker M1)
!   |S21| within 3 dB of that: 759.3 MHz to 2.74 GHz (1.981 GHz wide, 113 % of centre) (the widest 1 of 2)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -44.2  -  -
! 120.6 kHz  -  -50.5  -  -
! 635.6 kHz  -  -53.1  -  -
! 4.039 MHz  -  -55.8  -  -
! 5.791 MHz  -  -75.2  -  -
! 25.5 MHz  -  -63.2  -  -
! 32.72 MHz  -  -51.9  -  -
! 65.85 MHz  -  -52.6  -  -
! 85.68 MHz  -  -29.5  -  -
! 106.9 MHz  -  -28.4  -  -
! 162 MHz  -  3.6  -  -
! 364.4 MHz  -  59.2  -  -
! 1.03 GHz  -  61.5  -  -
! 2.348 GHz  -  62.6  -  -
! 2.773 GHz  -  56.6  -  -
! 3.163 GHz  -  8.8  -  -
! 3.437 GHz  -  20.1  -  -
! 4.41 GHz  -  -29.8  -  -
! 4.996 GHz  -  -26.4  -  -
! 5.467 GHz  -  -48.7  -  -
! 6.15 GHz  -  -25.3  -  -
! 6.5 GHz  -  -35.1  -  -
