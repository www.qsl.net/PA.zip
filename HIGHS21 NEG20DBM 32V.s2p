!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 19:31:43
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 63.1 dB at 2.381 GHz (marker M1)
!   |S21| within 3 dB of that: 1.902 GHz to 3.31 GHz (1.408 GHz wide, 54 % of centre) (the widest 1 of 4)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -48.5  -  -
! 635.6 kHz  -  -59.8  -  -
! 1.965 MHz  -  -52.0  -  -
! 2.857 MHz  -  -59.5  -  -
! 4.039 MHz  -  -64.9  -  -
! 25.5 MHz  -  -68.4  -  -
! 38.1 MHz  -  -51.2  -  -
! 69.6 MHz  -  -63.7  -  -
! 162 MHz  -  -48.5  -  -
! 243.8 MHz  -  -64.1  -  -
! 278.1 MHz  -  -51.3  -  -
! 374.6 MHz  -  -55.3  -  -
! 470.8 MHz  -  -33.8  -  -
! 878.2 MHz  -  -9.7  -  -
! 1.03 GHz  -  -22.7  -  -
! 1.089 GHz  -  -19.4  -  -
! 1.466 GHz  -  34.8  -  -
! 1.731 GHz  -  52.3  -  -
! 1.934 GHz  -  61.1  -  -
! 2.381 GHz  -  63.1  -  -
! 5.698 GHz  -  61.8  -  -
! 6.5 GHz  -  48.7  -  -
