!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 19:02:34
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 57.6 dB at 216.7 MHz (marker M1)
!   |S21| within 3 dB of that: 6.4 MHz to 525.8 MHz (519.4 MHz wide, 195 % of centre)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -23.2  -  -
! 126.6 kHz  -  -30.5  -  -
! 134.7 kHz  -  -26.3  -  -
! 236 kHz  -  -28.8  -  -
! 399.6 kHz  -  -38.2  -  -
! 635.6 kHz  -  -8.3  -  -
! 787.8 kHz  -  2.0  -  -
! 930.2 kHz  -  -0.8  -  -
! 1.083 MHz  -  15.5  -  -
! 1.334 MHz  -  23.5  -  -
! 4.039 MHz  -  50.9  -  -
! 25.5 MHz  -  57.6  -  -
! 162 MHz  -  57.2  -  -
! 216.7 MHz  -  57.6  -  -
! 679.6 MHz  -  52.9  -  -
! 748.9 MHz  -  45.3  -  -
! 909.1 MHz  -  17.4  -  -
! 1.03 GHz  -  6.5  -  -
! 1.096 GHz  -  2.9  -  -
! 1.199 GHz  -  -42.3  -  -
! 1.294 GHz  -  -34.9  -  -
! 6.5 GHz  -  -39.5  -  -
