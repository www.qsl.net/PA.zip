!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 19:31:18
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 62.8 dB at 2.381 GHz (marker M1)
!   |S21| within 3 dB of that: 1.9 GHz to 3.309 GHz (1.409 GHz wide, 54.1 % of centre) (the widest 1 of 4)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -48.6  -  -
! 635.6 kHz  -  -55.6  -  -
! 1.129 MHz  -  -51.4  -  -
! 1.469 MHz  -  -60.5  -  -
! 2.077 MHz  -  -56.1  -  -
! 4.039 MHz  -  -62.3  -  -
! 4.482 MHz  -  -67.7  -  -
! 25.5 MHz  -  -58.1  -  -
! 47.23 MHz  -  -49.8  -  -
! 69.12 MHz  -  -69.9  -  -
! 106.2 MHz  -  -53.4  -  -
! 162 MHz  -  -54.9  -  -
! 207.9 MHz  -  -48.6  -  -
! 306.4 MHz  -  -55.0  -  -
! 878.2 MHz  -  -10.1  -  -
! 1.03 GHz  -  -22.5  -  -
! 1.089 GHz  -  -19.9  -  -
! 1.466 GHz  -  34.6  -  -
! 1.731 GHz  -  52.1  -  -
! 2.381 GHz  -  62.8  -  -
! 5.698 GHz  -  61.5  -  -
! 6.5 GHz  -  48.2  -  -
