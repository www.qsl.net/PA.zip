!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 19:33:34
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 64.9 dB at 1.961 GHz (marker M1)
!   |S21| within 3 dB of that: 1.769 GHz to 3.348 GHz (1.579 GHz wide, 61.7 % of centre) (the widest 1 of 10)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -31.5  -  -
! 133.8 kHz  -  -30.4  -  -
! 171.6 kHz  -  -25.3  -  -
! 278.7 kHz  -  -29.0  -  -
! 320.2 kHz  -  -34.4  -  -
! 428.2 kHz  -  -20.8  -  -
! 635.6 kHz  -  -35.5  -  -
! 4.039 MHz  -  -37.2  -  -
! 25.5 MHz  -  -60.7  -  -
! 36.55 MHz  -  -35.0  -  -
! 60.6 MHz  -  -35.8  -  -
! 74.59 MHz  -  -28.7  -  -
! 137.2 MHz  -  -35.9  -  -
! 162 MHz  -  -33.1  -  -
! 467.6 MHz  -  -36.1  -  -
! 634.2 MHz  -  -22.8  -  -
! 713.4 MHz  -  -27.9  -  -
! 1.03 GHz  -  -34.2  -  -
! 1.604 GHz  -  51.4  -  -
! 1.961 GHz  -  64.9  -  -
! 5.698 GHz  -  62.3  -  -
! 6.5 GHz  -  49.1  -  -
