!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 19:04:36
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 56.0 dB at 418.5 MHz (marker M1)
!   |S21| within 3 dB of that: 5.599 MHz to 542.4 MHz (536.8 MHz wide, 196 % of centre)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -49.2  -  -
! 338.4 kHz  -  -53.3  -  -
! 635.6 kHz  -  -8.4  -  -
! 1.39 MHz  -  24.7  -  -
! 4.039 MHz  -  49.9  -  -
! 25.5 MHz  -  55.0  -  -
! 162 MHz  -  54.2  -  -
! 418.5 MHz  -  56.0  -  -
! 703.6 MHz  -  49.2  -  -
! 915.4 MHz  -  16.6  -  -
! 1.03 GHz  -  6.0  -  -
! 1.104 GHz  -  -2.3  -  -
! 1.259 GHz  -  -63.5  -  -
! 1.368 GHz  -  -83.1  -  -
! 1.792 GHz  -  -58.8  -  -
! 2.253 GHz  -  -66.1  -  -
! 2.623 GHz  -  -49.5  -  -
! 3.229 GHz  -  -79.7  -  -
! 3.787 GHz  -  -52.0  -  -
! 4.534 GHz  -  -63.4  -  -
! 5.859 GHz  -  -61.0  -  -
! 6.5 GHz  -  -66.5  -  -
