!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 19:33:06
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 64.5 dB at 1.948 GHz (marker M1)
!   |S21| within 3 dB of that: 1.765 GHz to 3.348 GHz (1.583 GHz wide, 61.9 % of centre) (the widest 1 of 9)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -23.8  -  -
! 112.5 kHz  -  -49.9  -  -
! 635.6 kHz  -  -34.0  -  -
! 1.664 MHz  -  -30.9  -  -
! 2.181 MHz  -  -45.1  -  -
! 2.857 MHz  -  -36.1  -  -
! 4.039 MHz  -  -39.9  -  -
! 25.5 MHz  -  -52.7  -  -
! 38.36 MHz  -  -31.2  -  -
! 46.58 MHz  -  -41.7  -  -
! 162 MHz  -  -27.9  -  -
! 248.9 MHz  -  -35.6  -  -
! 296 MHz  -  -31.2  -  -
! 379.8 MHz  -  -24.9  -  -
! 454.8 MHz  -  -42.6  -  -
! 679.6 MHz  -  -28.5  -  -
! 1.03 GHz  -  -33.8  -  -
! 1.593 GHz  -  50.3  -  -
! 1.731 GHz  -  59.8  -  -
! 1.948 GHz  -  64.5  -  -
! 5.698 GHz  -  61.8  -  -
! 6.5 GHz  -  48.5  -  -
