!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 19:37:39
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 57.1 dB at 5.659 GHz (marker M1)
!   |S21| within 3 dB of that: 1.898 GHz to 6.204 GHz (4.306 GHz wide, 106 % of centre)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -59.8  -  -
! 635.6 kHz  -  -76.8  -  -
! 4.039 MHz  -  -73.1  -  -
! 18.28 MHz  -  -82.6  -  -
! 25.5 MHz  -  -66.5  -  -
! 35.55 MHz  -  -68.9  -  -
! 72.56 MHz  -  -71.1  -  -
! 92.46 MHz  -  -66.0  -  -
! 105.5 MHz  -  -65.8  -  -
! 162 MHz  -  -51.1  -  -
! 202.2 MHz  -  -45.8  -  -
! 248.9 MHz  -  -51.0  -  -
! 349.5 MHz  -  -41.5  -  -
! 643 MHz  -  -6.3  -  -
! 775.2 MHz  -  -19.2  -  -
! 884.3 MHz  -  13.0  -  -
! 1.03 GHz  -  -0.4  -  -
! 1.216 GHz  -  3.0  -  -
! 1.649 GHz  -  43.4  -  -
! 1.908 GHz  -  54.3  -  -
! 5.659 GHz  -  57.1  -  -
! 6.5 GHz  -  47.7  -  -
