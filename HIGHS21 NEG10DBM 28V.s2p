!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 19:40:37
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 59.0 dB at 2.773 GHz (marker M1)
!   |S21| within 3 dB of that: 1.91 GHz to 6.104 GHz (4.194 GHz wide, 105 % of centre)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -55.7  -  -
! 635.6 kHz  -  -69.7  -  -
! 4.039 MHz  -  -66.3  -  -
! 6.38 MHz  -  -75.6  -  -
! 25.5 MHz  -  -75.9  -  -
! 39.72 MHz  -  -61.3  -  -
! 77.22 MHz  -  -58.9  -  -
! 147.1 MHz  -  -53.9  -  -
! 162 MHz  -  -54.5  -  -
! 333 MHz  -  -54.5  -  -
! 442.4 MHz  -  -28.0  -  -
! 643 MHz  -  -8.2  -  -
! 780.6 MHz  -  -19.6  -  -
! 890.4 MHz  -  6.2  -  -
! 1.03 GHz  -  -5.1  -  -
! 1.096 GHz  -  -7.5  -  -
! 1.25 GHz  -  -9.9  -  -
! 1.638 GHz  -  43.2  -  -
! 1.843 GHz  -  54.5  -  -
! 2.773 GHz  -  59.0  -  -
! 5.698 GHz  -  58.6  -  -
! 6.5 GHz  -  47.9  -  -
