!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 15:14:36
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 63.6 dB at 2.348 GHz (marker M1)
!   |S21| within 3 dB of that: 1.401 GHz to 2.749 GHz (1.349 GHz wide, 65 % of centre) (the widest 1 of 4)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -50.6  -  -
! 635.6 kHz  -  -53.0  -  -
! 4.039 MHz  -  -63.6  -  -
! 25.5 MHz  -  -66.8  -  -
! 29.9 MHz  -  -66.9  -  -
! 34.34 MHz  -  -43.8  -  -
! 53.5 MHz  -  -45.8  -  -
! 86.27 MHz  -  -25.8  -  -
! 106.2 MHz  -  -29.1  -  -
! 162 MHz  -  4.7  -  -
! 359.4 MHz  -  59.7  -  -
! 1.03 GHz  -  62.4  -  -
! 2.348 GHz  -  63.6  -  -
! 2.792 GHz  -  56.6  -  -
! 3.141 GHz  -  13.5  -  -
! 3.461 GHz  -  19.6  -  -
! 4.144 GHz  -  -33.9  -  -
! 4.441 GHz  -  -20.2  -  -
! 4.996 GHz  -  -25.5  -  -
! 5.467 GHz  -  -49.8  -  -
! 6.15 GHz  -  -24.6  -  -
! 6.5 GHz  -  -34.2  -  -
