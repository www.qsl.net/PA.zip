!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Tuesday, August 29, 2023 20:25:24
!Correction: S11(Off)
!S1P File: Measurement: S11:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (reflecting one-port):
!   1601 points, 10 MHz to 7 GHz, reference 50 ohm
!   lowest |S11| = -2.5 dB at 6.267 GHz (marker M1), VSWR 7.00, Z = 34.6 + j93.1 ohm
!   phase of S11 starts at -38 deg and turns -26419 deg over the sweep
!   the Smith chart shows 6.191 GHz to 6.371 GHz only
!   S11 on the Smith chart (normalised r, x): 6.191 GHz: 7.62, +1.13; 6.242 GHz: 0.13, +0.18; 6.293 GHz: 0.50, -1.65; 6.345 GHz: 0.12, +0.45; 6.371 GHz: 0.70, +2.15
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! magnitudes (dB):
! f  S11
! 10 MHz  0.0
! 22.68 MHz  0.0
! 51.65 MHz  -0.2
! 117.1 MHz  -0.2
! 264.6 MHz  -0.4
! 600 MHz  -0.6
! 1.361 GHz  -0.9
! 1.465 GHz  -1.1
! 1.975 GHz  -1.2
! 2.135 GHz  -1.2
! 3.086 GHz  -1.3
! 3.757 GHz  -1.7
! 4.23 GHz  -1.6
! 4.318 GHz  -1.9
! 4.407 GHz  -1.5
! 4.535 GHz  -2.0
! 4.61 GHz  -1.6
! 4.922 GHz  -2.1
! 5.475 GHz  -1.9
! 5.967 GHz  -1.6
! 6.191 GHz  -2.2
! 6.242 GHz  -2.2
! 6.267 GHz  -2.5
! 6.293 GHz  -2.2
! 6.345 GHz  -1.8
! 6.371 GHz  -2.0
! 6.637 GHz  -2.3
! 7 GHz  -1.9
