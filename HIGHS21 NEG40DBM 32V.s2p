!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 19:33:59
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 65.3 dB at 1.961 GHz (marker M1)
!   |S21| within 3 dB of that: 1.774 GHz to 3.351 GHz (1.577 GHz wide, 61.5 % of centre) (the widest 1 of 7)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -32.5  -  -
! 246.1 kHz  -  -30.1  -  -
! 635.6 kHz  -  -35.2  -  -
! 4.039 MHz  -  -42.6  -  -
! 14.45 MHz  -  -42.3  -  -
! 18.54 MHz  -  -41.5  -  -
! 20.29 MHz  -  -40.3  -  -
! 25.5 MHz  -  -38.1  -  -
! 39.72 MHz  -  -48.7  -  -
! 62.3 MHz  -  -31.6  -  -
! 69.12 MHz  -  -33.3  -  -
! 77.76 MHz  -  -31.4  -  -
! 86.87 MHz  -  -32.4  -  -
! 162 MHz  -  -38.6  -  -
! 242.1 MHz  -  -44.3  -  -
! 359.4 MHz  -  -26.2  -  -
! 1.03 GHz  -  -30.6  -  -
! 1.604 GHz  -  51.4  -  -
! 1.743 GHz  -  60.7  -  -
! 1.961 GHz  -  65.3  -  -
! 5.738 GHz  -  61.8  -  -
! 6.5 GHz  -  49.6  -  -
