!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 19:01:53
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 57.1 dB at 21.89 MHz (marker M1)
!   |S21| within 3 dB of that: 6.279 MHz to 531.5 MHz (525.2 MHz wide, 195 % of centre)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -22.2  -  -
! 112.5 kHz  -  -33.9  -  -
! 350.3 kHz  -  -27.4  -  -
! 465.4 kHz  -  -28.4  -  -
! 635.6 kHz  -  -8.8  -  -
! 787.8 kHz  -  0.9  -  -
! 930.2 kHz  -  -1.5  -  -
! 1.306 MHz  -  22.8  -  -
! 4.039 MHz  -  50.5  -  -
! 21.89 MHz  -  57.1  -  -
! 25.5 MHz  -  57.0  -  -
! 162 MHz  -  56.7  -  -
! 675 MHz  -  52.8  -  -
! 1.03 GHz  -  5.2  -  -
! 1.081 GHz  -  10.5  -  -
! 1.175 GHz  -  -33.9  -  -
! 1.242 GHz  -  -41.0  -  -
! 2.871 GHz  -  -32.3  -  -
! 3.32 GHz  -  -37.2  -  -
! 3.608 GHz  -  -41.2  -  -
! 4.173 GHz  -  -36.8  -  -
! 6.5 GHz  -  -30.6  -  -
