!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 15:23:35
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 60.5 dB at 1.768 GHz (marker M1)
!   |S21| within 3 dB of that: 700 MHz to 2.744 GHz (2.044 GHz wide, 119 % of centre) (the widest 1 of 2)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -55.6  -  -
! 635.6 kHz  -  -53.7  -  -
! 4.039 MHz  -  -51.6  -  -
! 25.5 MHz  -  -53.2  -  -
! 52.76 MHz  -  -48.3  -  -
! 86.87 MHz  -  -11.1  -  -
! 118.6 MHz  -  -15.0  -  -
! 162 MHz  -  6.1  -  -
! 240.5 MHz  -  27.4  -  -
! 354.4 MHz  -  56.5  -  -
! 1.03 GHz  -  59.0  -  -
! 1.768 GHz  -  60.5  -  -
! 2.735 GHz  -  58.0  -  -
! 2.89 GHz  -  46.9  -  -
! 3.163 GHz  -  11.7  -  -
! 3.437 GHz  -  21.0  -  -
! 3.761 GHz  -  -17.7  -  -
! 4.41 GHz  -  -28.6  -  -
! 4.996 GHz  -  -24.4  -  -
! 5.467 GHz  -  -52.6  -  -
! 6.15 GHz  -  -24.4  -  -
! 6.5 GHz  -  -34.1  -  -
