!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 15:18:11
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 65.4 dB at 928.2 MHz (marker M1)
!   |S21| within 3 dB of that: 1.208 GHz to 1.908 GHz (699.5 MHz wide, 44.9 % of centre) (the widest 1 of 5)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -24.4  -  -
! 118.9 kHz  -  -35.7  -  -
! 151.5 kHz  -  -23.9  -  -
! 187.8 kHz  -  -36.2  -  -
! 231.2 kHz  -  -30.4  -  -
! 635.6 kHz  -  -31.4  -  -
! 4.039 MHz  -  -41.5  -  -
! 25.5 MHz  -  -44.0  -  -
! 28.88 MHz  -  -43.0  -  -
! 34.82 MHz  -  -25.9  -  -
! 92.46 MHz  -  -30.3  -  -
! 118.6 MHz  -  -16.1  -  -
! 162 MHz  -  4.7  -  -
! 352 MHz  -  60.0  -  -
! 928.2 MHz  -  65.4  -  -
! 1.03 GHz  -  64.0  -  -
! 2.66 GHz  -  63.7  -  -
! 2.851 GHz  -  51.0  -  -
! 3.141 GHz  -  13.3  -  -
! 3.461 GHz  -  19.5  -  -
! 4.144 GHz  -  -38.1  -  -
! 6.5 GHz  -  -28.9  -  -
