!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 19:04:09
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 55.7 dB at 424.4 MHz (marker M1)
!   |S21| within 3 dB of that: 5.497 MHz to 548.2 MHz (542.7 MHz wide, 196 % of centre)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -52.5  -  -
! 347.9 kHz  -  -57.6  -  -
! 635.6 kHz  -  -9.0  -  -
! 1.371 MHz  -  24.2  -  -
! 4.039 MHz  -  49.9  -  -
! 25.5 MHz  -  54.7  -  -
! 162 MHz  -  53.9  -  -
! 424.4 MHz  -  55.7  -  -
! 703.6 MHz  -  49.1  -  -
! 1.03 GHz  -  5.3  -  -
! 1.104 GHz  -  -2.8  -  -
! 1.259 GHz  -  -59.8  -  -
! 1.368 GHz  -  -68.6  -  -
! 1.487 GHz  -  -76.4  -  -
! 1.843 GHz  -  -64.3  -  -
! 2.284 GHz  -  -69.1  -  -
! 2.623 GHz  -  -50.3  -  -
! 3.252 GHz  -  -76.7  -  -
! 3.761 GHz  -  -54.0  -  -
! 4.534 GHz  -  -62.3  -  -
! 5.899 GHz  -  -63.1  -  -
! 6.5 GHz  -  -71.8  -  -
