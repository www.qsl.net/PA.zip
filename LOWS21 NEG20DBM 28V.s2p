!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 18:55:05
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 57.1 dB at 424.4 MHz (marker M1)
!   |S21| within 3 dB of that: 6.415 MHz to 529.5 MHz (523.1 MHz wide, 195 % of centre)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -40.2  -  -
! 180.2 kHz  -  -48.5  -  -
! 232.8 kHz  -  -59.2  -  -
! 357.7 kHz  -  -51.1  -  -
! 635.6 kHz  -  -9.5  -  -
! 782.3 kHz  -  0.9  -  -
! 923.8 kHz  -  -1.2  -  -
! 1.306 MHz  -  22.7  -  -
! 4.039 MHz  -  50.4  -  -
! 25.5 MHz  -  56.5  -  -
! 162 MHz  -  55.9  -  -
! 424.4 MHz  -  57.1  -  -
! 698.7 MHz  -  50.7  -  -
! 1.03 GHz  -  5.2  -  -
! 1.104 GHz  -  -2.9  -  -
! 1.216 GHz  -  -51.5  -  -
! 1.321 GHz  -  -59.3  -  -
! 2.03 GHz  -  -58.3  -  -
! 2.642 GHz  -  -44.1  -  -
! 3.163 GHz  -  -61.7  -  -
! 6.065 GHz  -  -53.5  -  -
! 6.5 GHz  -  -65.3  -  -
