!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 19:38:58
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 57.8 dB at 5.659 GHz (marker M1)
!   |S21| within 3 dB of that: 1.89 GHz to 6.203 GHz (4.313 GHz wide, 107 % of centre)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -54.1  -  -
! 109.4 kHz  -  -61.8  -  -
! 172.8 kHz  -  -65.0  -  -
! 635.6 kHz  -  -67.4  -  -
! 4.039 MHz  -  -71.2  -  -
! 25.5 MHz  -  -80.8  -  -
! 48.55 MHz  -  -66.8  -  -
! 65.4 MHz  -  -65.3  -  -
! 93.75 MHz  -  -78.7  -  -
! 162 MHz  -  -49.2  -  -
! 199.5 MHz  -  -45.1  -  -
! 242.1 MHz  -  -46.9  -  -
! 335.3 MHz  -  -41.7  -  -
! 652 MHz  -  -5.6  -  -
! 769.9 MHz  -  -11.6  -  -
! 884.3 MHz  -  13.3  -  -
! 1.03 GHz  -  0.6  -  -
! 1.216 GHz  -  3.6  -  -
! 1.649 GHz  -  43.9  -  -
! 1.908 GHz  -  55.2  -  -
! 5.659 GHz  -  57.8  -  -
! 6.5 GHz  -  48.3  -  -
