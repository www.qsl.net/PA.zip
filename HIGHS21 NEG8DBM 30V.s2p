!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 19:38:14
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 57.5 dB at 5.659 GHz (marker M1)
!   |S21| within 3 dB of that: 1.894 GHz to 6.204 GHz (4.309 GHz wide, 106 % of centre)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -63.9  -  -
! 357.7 kHz  -  -66.9  -  -
! 443.3 kHz  -  -65.6  -  -
! 635.6 kHz  -  -78.7  -  -
! 4.039 MHz  -  -70.3  -  -
! 25.5 MHz  -  -71.1  -  -
! 29.08 MHz  -  -79.9  -  -
! 32.49 MHz  -  -63.7  -  -
! 41.98 MHz  -  -62.9  -  -
! 57.73 MHz  -  -79.1  -  -
! 125.4 MHz  -  -68.4  -  -
! 162 MHz  -  -55.4  -  -
! 364.4 MHz  -  -41.3  -  -
! 643 MHz  -  -6.0  -  -
! 775.2 MHz  -  -17.2  -  -
! 884.3 MHz  -  13.2  -  -
! 1.03 GHz  -  0.1  -  -
! 1.216 GHz  -  3.3  -  -
! 1.649 GHz  -  43.7  -  -
! 1.908 GHz  -  54.8  -  -
! 5.659 GHz  -  57.5  -  -
! 6.5 GHz  -  48.1  -  -
