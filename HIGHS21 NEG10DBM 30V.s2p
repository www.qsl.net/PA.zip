!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 19:40:08
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 59.4 dB at 2.773 GHz (marker M1)
!   |S21| within 3 dB of that: 1.907 GHz to 6.102 GHz (4.195 GHz wide, 105 % of centre)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -55.4  -  -
! 118.1 kHz  -  -56.6  -  -
! 523.5 kHz  -  -61.8  -  -
! 635.6 kHz  -  -66.5  -  -
! 4.039 MHz  -  -69.6  -  -
! 25.5 MHz  -  -81.7  -  -
! 33.4 MHz  -  -71.8  -  -
! 54.24 MHz  -  -68.1  -  -
! 162 MHz  -  -62.3  -  -
! 210.8 MHz  -  -49.4  -  -
! 328.4 MHz  -  -47.9  -  -
! 442.4 MHz  -  -27.8  -  -
! 643 MHz  -  -8.1  -  -
! 780.6 MHz  -  -18.3  -  -
! 890.4 MHz  -  6.4  -  -
! 1.03 GHz  -  -4.3  -  -
! 1.096 GHz  -  -7.1  -  -
! 1.259 GHz  -  -7.0  -  -
! 1.843 GHz  -  54.9  -  -
! 2.773 GHz  -  59.4  -  -
! 5.698 GHz  -  58.9  -  -
! 6.5 GHz  -  48.3  -  -
