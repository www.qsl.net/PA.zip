!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 15:14:45
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 64.4 dB at 2.348 GHz (marker M1)
!   |S21| within 3 dB of that: 2.176 GHz to 2.758 GHz (582.1 MHz wide, 23.6 % of centre) (the widest 1 of 7)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -50.0  -  -
! 635.6 kHz  -  -58.6  -  -
! 4.039 MHz  -  -55.0  -  -
! 25.5 MHz  -  -62.1  -  -
! 29.08 MHz  -  -66.4  -  -
! 33.63 MHz  -  -49.8  -  -
! 64.05 MHz  -  -56.6  -  -
! 88.7 MHz  -  -22.9  -  -
! 109.2 MHz  -  -26.3  -  -
! 162 MHz  -  5.8  -  -
! 356.9 MHz  -  60.2  -  -
! 1.03 GHz  -  63.2  -  -
! 2.348 GHz  -  64.4  -  -
! 2.811 GHz  -  56.4  -  -
! 3.141 GHz  -  15.7  -  -
! 3.461 GHz  -  21.1  -  -
! 4.144 GHz  -  -32.8  -  -
! 4.441 GHz  -  -19.6  -  -
! 4.996 GHz  -  -24.0  -  -
! 5.467 GHz  -  -47.7  -  -
! 6.15 GHz  -  -24.6  -  -
! 6.5 GHz  -  -32.6  -  -
