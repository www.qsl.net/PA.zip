!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 15:17:54
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 66.3 dB at 934.7 MHz (marker M1)
!   |S21| within 3 dB of that: 1.459 GHz to 1.824 GHz (364.9 MHz wide, 22.2 % of centre) (the widest 1 of 6)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -28.5  -  -
! 516.3 kHz  -  -30.9  -  -
! 635.6 kHz  -  -48.8  -  -
! 4.039 MHz  -  -39.5  -  -
! 25.5 MHz  -  -37.2  -  -
! 28.88 MHz  -  -43.0  -  -
! 32.49 MHz  -  -41.5  -  -
! 98.41 MHz  -  -36.2  -  -
! 162 MHz  -  5.5  -  -
! 349.5 MHz  -  60.3  -  -
! 934.7 MHz  -  66.3  -  -
! 1.03 GHz  -  64.6  -  -
! 2.678 GHz  -  64.1  -  -
! 2.89 GHz  -  49.1  -  -
! 3.163 GHz  -  13.0  -  -
! 3.461 GHz  -  20.9  -  -
! 3.761 GHz  -  -17.4  -  -
! 4.144 GHz  -  -30.6  -  -
! 4.996 GHz  -  -22.9  -  -
! 5.354 GHz  -  -29.9  -  -
! 6.023 GHz  -  -18.7  -  -
! 6.5 GHz  -  -30.4  -  -
