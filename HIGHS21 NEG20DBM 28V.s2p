!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 19:29:58
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 62.5 dB at 2.381 GHz (marker M1)
!   |S21| within 3 dB of that: 1.899 GHz to 3.309 GHz (1.41 GHz wide, 54.2 % of centre) (the widest 1 of 3)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -42.6  -  -
! 164.7 kHz  -  -51.8  -  -
! 313.6 kHz  -  -52.0  -  -
! 635.6 kHz  -  -59.9  -  -
! 4.039 MHz  -  -59.0  -  -
! 25.5 MHz  -  -71.1  -  -
! 38.1 MHz  -  -60.8  -  -
! 51.67 MHz  -  -57.0  -  -
! 78.3 MHz  -  -53.8  -  -
! 90.56 MHz  -  -52.6  -  -
! 162 MHz  -  -62.6  -  -
! 344.7 MHz  -  -46.2  -  -
! 467.6 MHz  -  -33.4  -  -
! 878.2 MHz  -  -10.6  -  -
! 1.03 GHz  -  -23.8  -  -
! 1.089 GHz  -  -20.8  -  -
! 1.456 GHz  -  33.4  -  -
! 1.719 GHz  -  51.3  -  -
! 1.934 GHz  -  60.5  -  -
! 2.381 GHz  -  62.5  -  -
! 5.659 GHz  -  61.5  -  -
! 6.5 GHz  -  47.7  -  -
