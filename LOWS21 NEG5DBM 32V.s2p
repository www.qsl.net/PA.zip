!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 19:05:02
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 56.1 dB at 412.8 MHz (marker M1)
!   |S21| within 3 dB of that: 5.692 MHz to 538.1 MHz (532.4 MHz wide, 196 % of centre)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -53.3  -  -
! 345.5 kHz  -  -54.5  -  -
! 635.6 kHz  -  -7.8  -  -
! 1.419 MHz  -  25.4  -  -
! 4.039 MHz  -  50.0  -  -
! 25.5 MHz  -  55.2  -  -
! 162 MHz  -  54.4  -  -
! 412.8 MHz  -  56.1  -  -
! 698.7 MHz  -  49.4  -  -
! 909.1 MHz  -  17.4  -  -
! 1.03 GHz  -  6.6  -  -
! 1.104 GHz  -  -1.8  -  -
! 1.259 GHz  -  -57.8  -  -
! 1.436 GHz  -  -72.6  -  -
! 1.755 GHz  -  -64.7  -  -
! 2.237 GHz  -  -69.6  -  -
! 2.623 GHz  -  -50.3  -  -
! 3.229 GHz  -  -74.5  -  -
! 3.761 GHz  -  -51.3  -  -
! 4.441 GHz  -  -62.4  -  -
! 5.859 GHz  -  -61.3  -  -
! 6.5 GHz  -  -73.3  -  -
