!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 15:24:10
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 61.0 dB at 1.768 GHz (marker M1)
!   |S21| within 3 dB of that: 707.6 MHz to 2.753 GHz (2.046 GHz wide, 118 % of centre) (the widest 1 of 2)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -60.2  -  -
! 249.5 kHz  -  -51.5  -  -
! 635.6 kHz  -  -56.8  -  -
! 4.039 MHz  -  -51.6  -  -
! 25.5 MHz  -  -51.7  -  -
! 51.67 MHz  -  -46.2  -  -
! 86.87 MHz  -  -9.2  -  -
! 119.5 MHz  -  -14.3  -  -
! 162 MHz  -  7.3  -  -
! 356.9 MHz  -  57.3  -  -
! 1.03 GHz  -  59.5  -  -
! 1.768 GHz  -  61.0  -  -
! 2.735 GHz  -  58.7  -  -
! 2.89 GHz  -  48.2  -  -
! 3.163 GHz  -  13.5  -  -
! 3.437 GHz  -  21.8  -  -
! 3.761 GHz  -  -16.3  -  -
! 4.41 GHz  -  -28.2  -  -
! 4.996 GHz  -  -22.5  -  -
! 5.467 GHz  -  -53.5  -  -
! 6.15 GHz  -  -23.3  -  -
! 6.5 GHz  -  -33.7  -  -
