!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 19:02:13
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 57.4 dB at 221.3 MHz (marker M1)
!   |S21| within 3 dB of that: 6.325 MHz to 528.6 MHz (522.3 MHz wide, 195 % of centre)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -32.2  -  -
! 402.4 kHz  -  -29.1  -  -
! 465.4 kHz  -  -23.9  -  -
! 635.6 kHz  -  -9.2  -  -
! 787.8 kHz  -  1.7  -  -
! 930.2 kHz  -  -1.5  -  -
! 1.306 MHz  -  22.8  -  -
! 4.039 MHz  -  50.7  -  -
! 25.5 MHz  -  57.3  -  -
! 162 MHz  -  57.0  -  -
! 221.3 MHz  -  57.4  -  -
! 679.6 MHz  -  52.7  -  -
! 1.03 GHz  -  5.9  -  -
! 1.096 GHz  -  2.3  -  -
! 1.183 GHz  -  -39.9  -  -
! 1.25 GHz  -  -46.1  -  -
! 1.34 GHz  -  -35.8  -  -
! 1.843 GHz  -  -39.7  -  -
! 2.237 GHz  -  -34.6  -  -
! 2.552 GHz  -  -47.1  -  -
! 4.03 GHz  -  -35.3  -  -
! 6.5 GHz  -  -40.8  -  -
