!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 18:56:20
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 57.4 dB at 232.3 MHz (marker M1)
!   |S21| within 3 dB of that: 6.358 MHz to 528.6 MHz (522.3 MHz wide, 195 % of centre)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -63.4  -  -
! 106.4 kHz  -  -42.6  -  -
! 127.4 kHz  -  -38.2  -  -
! 199.9 kHz  -  -59.1  -  -
! 333.7 kHz  -  -50.2  -  -
! 635.6 kHz  -  -8.3  -  -
! 923.8 kHz  -  -0.5  -  -
! 1.334 MHz  -  23.5  -  -
! 4.039 MHz  -  50.7  -  -
! 25.5 MHz  -  56.9  -  -
! 162 MHz  -  56.4  -  -
! 232.3 MHz  -  57.4  -  -
! 684.4 MHz  -  52.2  -  -
! 1.03 GHz  -  6.5  -  -
! 1.104 GHz  -  -1.9  -  -
! 1.242 GHz  -  -48.7  -  -
! 1.303 GHz  -  -75.0  -  -
! 2.268 GHz  -  -65.8  -  -
! 2.605 GHz  -  -49.0  -  -
! 3.098 GHz  -  -56.0  -  -
! 3.683 GHz  -  -53.0  -  -
! 6.5 GHz  -  -52.1  -  -
