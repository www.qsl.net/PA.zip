!Keysight Technologies,E5080B,MY59100498,A.17.05.10
!Date: Wednesday, August 30, 2023 15:23:04
!Correction: S11(C  Response)
!S21(C  Response)
!S12(C  Response)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:Log Frequency Sweep
# Hz S  dB  R 50
! Worked out from all points (amplifier or transistor):
!   1601 points, 100 kHz to 6.5 GHz, reference 50 ohm
!   highest |S21| = 60.0 dB at 1.768 GHz (marker M1)
!   |S21| within 3 dB of that: 390.9 MHz to 2.733 GHz (2.342 GHz wide, 150 % of centre)
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 kHz  -  -62.9  -  -
! 172.8 kHz  -  -50.2  -  -
! 635.6 kHz  -  -54.0  -  -
! 4.039 MHz  -  -53.9  -  -
! 25.5 MHz  -  -53.3  -  -
! 53.5 MHz  -  -48.2  -  -
! 86.87 MHz  -  -13.3  -  -
! 117.8 MHz  -  -16.5  -  -
! 162 MHz  -  4.6  -  -
! 354.4 MHz  -  55.7  -  -
! 1.03 GHz  -  58.3  -  -
! 1.768 GHz  -  60.0  -  -
! 2.716 GHz  -  57.6  -  -
! 2.89 GHz  -  45.3  -  -
! 3.163 GHz  -  9.4  -  -
! 3.437 GHz  -  20.0  -  -
! 3.761 GHz  -  -19.5  -  -
! 4.41 GHz  -  -29.3  -  -
! 4.996 GHz  -  -26.4  -  -
! 5.467 GHz  -  -53.1  -  -
! 6.15 GHz  -  -25.3  -  -
! 6.5 GHz  -  -34.5  -  -
